# Keil uVision project softlock_task.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51 Atmel Wireless & uC
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: softlock_task +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.C DES.c UART.c terminal.c
